# Keil uVision project Start_STM32F103.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Start_STM32F103 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=6
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER DEBUG=1
  c include: ..\..\..\Inc;DeviceSupport;SEGGER;.\STM32F10x_FWLib\inc;.\LED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep=_mutex_*
  group Application
    ./Application/: OS_StartLEDBlink.c
  group Application\Excluded
    ./Application/: OS_EventObjects.c OS_ExtendedTask.c OS_ExtendTaskContext.c OS_Mailboxes.c OS_MeasureCPU_Performance.c OS_MeasureCST_HRTimer_embOSView.c OS_MeasureCST_HRTimer_Printf.c OS_MeasureCST_Scope.c OS_Mutexes.c OS_ObjectIdentifier.c OS_Queues.c OS_Semaphores.c OS_Start2Tasks.c OS_Start2TasksEx.c OS_Stop.c OS_SWTimer.c OS_TaskStartHook.c OS_Watchdog.c OS_ReadersWriterLock.c
  group Setup
    ./Setup/: BSP.c JLINKMEM_Process.c OS_Error.c OS_InitSysStackInfo.c Retarget.c SEGGER_HardFaultHandler.c HardFaultHandler.S RTOSInit_STM32F1xx.c BSP_UART.c OS_ThreadSafe.c
  group Lib
    ../../../Lib/: osT7LDP.lib osT7LR.lib
  group DeviceSupport
    ./DeviceSupport/: system_stm32f10x.c startup_stm32f10x_hd.s
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c
  group SEGGER
    ./SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_embOS.c SEGGER_SYSVIEW_embOS.c SEGGER_RTT_ASM_ARMv7M.S
  group SEGGER\Excluded
    ./SEGGER/: SEGGER_RTT_Syscalls_KEIL.c
  group LED
    ./LED/: led.c
target Release (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Start_STM32F103
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\Inc;DeviceSupport;SEGGER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep=_mutex_*
software components: CMSIS:CORE 5.6.0
